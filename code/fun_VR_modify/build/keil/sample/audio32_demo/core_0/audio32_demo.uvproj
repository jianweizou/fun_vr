# Keil uVision project audio32_demo.uvproj, settings and files
target audio32_demo (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: core_0
  AfterMake: fromelf --bin ".\obj\core_0.axf" --output ".\obj\core_0.bin"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: printf=printf_uart, fprintf=fprintf_uart, USE_SONIX_CONFIG
  c misc: --gnu --forceinline --diag_suppress 177
  c include: ..\..\..\..\..\sdk\include;..\..\..\..\..\sdk\share\fatfs;..\..\..\..\..\sdk\driver\util;..\..\..\..\..\platform\freertos\include;..\..\..\..\..\bsp;..\..\..\..\..\config;..\core_0;..\..\..\..\..\project\sample\audio32_demo\core_0\CSpotter;..\..\..\..\..\project\sample\audio32_demo\core_0\H;..\..\..\..\..\sdk\share\sonix\audio;..\..\..\..\..\sdk\share\thirdparty\aud_driver;..\..\..\..\..\sdk\share\sonix\sw_i2c;..\..\..\..\..\sdk\share\thirdparty\fatfs;..\..\..\..\..\sdk\driver\i2s;..\..\..\..\..\sdk\include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x18000000 size 0x10000
  scatter file: .\snc_linker.sct
  link misc: --datacompressor off
  group app
    ../../../../../project/sample/audio32_demo/core_0/: main.c snx_audio_agc.c key.c led.c motor.c fun_main.c
    ../../../../../project/sample/audio32_demo/core_0/vr/: rd_wr_flash.s
    ../../../../../project/sample/audio32_demo/core_0/CSpotter/: DataFlashApi.c
  group bsp
    ../../../../../bsp/: bsp.c startup.s sonix_load_table.c
  group lib
    ../../../../../project/sample/audio32_demo/core_0/vr/: libCSpotterSDK_16k_24d_A_SNC7312_arm-cm3_V6.4.5_b20180726.lib
    ../../../../../sdk/lib/: snc7320_codec.lib snc7320_gpio.lib snc7320_i2c.lib snc7320_i2s.lib snc7320_idma.lib snc7320_spifc.lib snc7320_uart.lib snc7320_util.lib snc7320_timer_pwm.lib snc7320_saradc.lib
    ../../../../../sdk/share/sonix/audio/: audio.c rom_code_api.c
    ../../../../../sdk/share/sonix/sw_i2c/: I2C_Software_Master.c
    ../../../../../sdk/share/thirdparty/aud_driver/: aud_driver.c
    ../../../../../sdk/driver/i2s/: i2s4.c
    ../../../../../sdk/driver/uart/: uart.c
  group config
    ./: sonix_config.h
